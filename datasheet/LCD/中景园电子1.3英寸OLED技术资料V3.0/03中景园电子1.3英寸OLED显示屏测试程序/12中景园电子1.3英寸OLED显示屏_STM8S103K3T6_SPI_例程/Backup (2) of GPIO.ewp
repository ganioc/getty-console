# IAR project Backup (2) of GPIO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc; OLED_SRC
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_gpio.c
  group user
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_gpio.h
  group user/OLED
    OLED_SRC/: oled.c
